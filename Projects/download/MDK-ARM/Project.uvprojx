# Keil uVision project Project.uvprojx, settings and files
target FT32F030X (5060750::V5.06 update 6 (build 750)::.\ARMCC)
  device: FT32F030R8ATx FMD
  pack: FMD.FT32F0xx_DFP.1.0.1
  cpu: IRAM(0x20000000,0x00002000) IROM(0x08000000,0x00010000) CPUTYPE("Cortex-M0") CLOCK(12000000) ELITTLE
  output: ft32f0.hex +hex
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c define: FT32F030x8,USE_STDPERIPH_DRIVER,USE_FT32F072X8_EVAL,USE_DEFAULT_TIMEOUT_CALLBACK,FT32
  c include: ..\;..\..\..\Libraries\CMSIS\Device\FT\FT32F0xx\Include;..\..\..\Libraries\CMSIS\Include;..\..\..\Libraries\FT32F0xx_StdPeriph_Driver\inc;..\..\..\Libraries\FT32F0xx_CPAL_Driver\inc;..\..\..\Utilities\FT32_EVAL\Common;..\..\..\Utilities\FT32_EVAL\FT32F030xx_EVAL;..\..\..\develop_lib\hardware\st7789;..\..\..\develop_lib\ft_lib\gpio;..\..\..\develop_lib\hardware;..\..\..\develop_lib\middle_api;..\..\..\develop_lib\middle_api\tft_8080;..\..\..\develop_lib\ft_lib;..\..\..\develop_lib;..\..\meeting_machine_pro;..\..\..\develop_lib\ft_lib\i2c;..\..\..\develop_lib\ft_lib\common;..\..\..\develop_lib\ft_lib\timer;..\..\..\develop_lib\middle_api\queue;..\..\..\develop_lib\ft_lib\deprecated;..\..\..\develop_lib\middle_api\mid_bk953x
  library: MicroLIB
  memory RVCT4: ROM 0x8000000 size 0x10000
  memory RVCT9: RAM 0x20000000 size 0x2000
  group CMSIS
    ../: system_ft32f0xx.c
    ../../../Libraries/CMSIS/Device/FT/FT32F0xx/Source/Templates/arm/: startup_ft32f072xb.s
  group app
    ../: main.c ft32f0xx_it.c
  group StdPeriph_Driver
    ../../../Libraries/FT32F0xx_StdPeriph_Driver/src/: FT32f0xx_adc.c FT32f0xx_comp.c FT32f0xx_crc.c FT32f0xx_crs.c FT32f0xx_dac.c FT32f0xx_dbgmcu.c FT32f0xx_dma.c FT32f0xx_exti.c FT32f0xx_flash.c FT32f0xx_gpio.c FT32f0xx_i2c.c FT32f0xx_iwdg.c FT32f0xx_misc.c FT32f0xx_pwr.c FT32f0xx_rcc.c FT32f0xx_rtc.c FT32f0xx_spi.c FT32f0xx_syscfg.c FT32f0xx_tim.c FT32f0xx_usart.c FT32f0xx_wwdg.c
  group hardware
    ../../../develop_lib/hardware/st7789/: st7789.c
  group ft_lib
    ../../../develop_lib/ft_lib/gpio/: ft_gpio.c
    ../../../develop_lib/ft_lib/i2c/: ft_i2c.c
    ../../../develop_lib/ft_lib/timer/: ft_timer.c
    ../../../develop_lib/ft_lib/deprecated/: ft_delay.c
  group middle_api
    ../../../develop_lib/middle_api/tft_8080/: tft_8080.c
    ../../../develop_lib/middle_api/mid_bk953x/: mid_bk953x.c
